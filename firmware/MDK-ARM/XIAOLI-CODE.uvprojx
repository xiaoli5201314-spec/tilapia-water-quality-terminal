# Keil uVision project XIAOLI-CODE.uvprojx, settings and files
target XIAOLI-CODE (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80DFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: XIAOLI-CODE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Application/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../ThirdParty/jsmn
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xE0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Application
    ../Application/Src/: application.c status_led.c alarm_light.c relay_control.c brush_motor.c actuator.c sensor_power.c rs485.c modbus_rtu.c water_sensor.c esp12f_wifi.c air780_4g.c mqtt_transport.c network_manager.c cleaning_controller.c at_command.c uart_channel.c water_report.c water_reporter.c at_stream.c config_flash.c control_clock.c control_config.c control_protocol.c remote_control.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/Headers
    ../Application/Inc/: actuator.h air780_4g.h alarm_light.h application.h at_command.h board_config.h brush_motor.h cleaning_controller.h esp12f_wifi.h modbus_rtu.h mqtt_transport.h network_manager.h relay_control.h rs485.h sensor_power.h status_led.h uart_channel.h water_sensor.h network_config.h water_report.h water_reporter.h at_stream.h control_clock.h control_config.h control_protocol.h remote_control.h
    ../ThirdParty/jsmn/: jsmn.h
software components: CMSIS:CORE 4.3.0
